<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\DcoSmclkTest\DcoSmclkTest.ewp</path>
    </project>
    <batchBuild />
</workspace>
